## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "LDD"
	help
	  Includes the misc-modules and scull components into the root filesystem
```
